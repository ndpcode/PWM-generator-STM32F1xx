# Keil uVision project generator.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: generator +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\GenLibs;.\GenLibs\HD44780;.\GenLibs\MENU
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group GenLibs
    ./GenLibs/: bsc_stm32_delay.c gen_flash.c gen_ports.c gen_system.c gen_timers.c gen_menu.c gen_rtc.c
    ./GenLibs/HD44780/: hd44780display.c stm32f1xx_hd44780_driver.c
    ./GenLibs/MENU/: bsc_tree_menu.c bsc_controls.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
